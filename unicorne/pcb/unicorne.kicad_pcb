# Repository jwav/unicorne

File README.md:

<!--  -->
<!---->  <!---->
<!--  -->

# unicorne
a rehash of foostan's corne, but only with 1u keys. A uniform corne.

I'm not sure if it's worth doing, but I always felt that there should be a corne version where the 1.5u thumb keys are replaced with 1u keys.
This would make it a more easily sourceable keyboard and you don't really need 1.5u keys anyway.

# WARNING
Right now the project is still at the prototype stage. I haven't confirmed PCB viability.
Additionally, the project structure is wacky since I simply copypasted foostan's crkbd repo and removed most of what I didn't need to start modding the kicad files.

## KiCad design unicorne/pcb/unicorne.kicad_pcb

Board: 2 copper layers, 133.8 x 91.4 mm, 87 parts (4 on the bottom side), 70 nets.

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21: D; D3_SMD
J3: LED; StripLED_rev
JP2, JP3, JP4, JP5, JP6, JP7, JP8, JP9: Jumper
L1, L2, L3, L4, L5, L6, L7, L8, L9, L10, L11, L12, L13, L14, L15, L16, L17, L18, L19, L20, L21: SK6812MINI; SK6812MINI_rev
L22, L23, L24, L25, L26, L27: SK6812MINI; SK6812MINI_underglow_rev
OLED: OLED
P1, P2: i2c-pin; 1pin_conn
R1, R2: R
RSW1: Reset; ResetSW
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20: SW_PUSH; Choc_Hotswap
SW21: SW_PUSH; Choc_Hotswap_1.5u
TRRS: MJ-4PP-9
U1: ProMicro; ProMicro_v2
data: JPC2

Connections:
GND: J3.1, JP2.1, JP9.1, L1.2, L2.2, L3.2, L4.2, L5.2, L6.2, L7.2, L8.2, L9.2, L10.2, L11.2, L12.2, L13.2, L14.2, L15.2, L16.2, L17.2, L18.2, L19.2, L20.2, L21.2, L22.2, L23.2, L24.2, L25.2, L26.2, L27.2, RSW1.2, TRRS.C, U1.3, U1.4, U1.23
LED: J3.2, L24.3, U1.1
unnamed: D1.2, SW1.2
unnamed: D2.2, SW2.2
unnamed: D3.2, SW3.2
unnamed: D4.2, SW4.2
unnamed: D5.2, SW5.2
unnamed: D6.2, SW6.2
unnamed: D7.2, SW7.2
unnamed: D8.2, SW8.2
unnamed: D9.2, SW9.2
unnamed: D10.2, SW10.2
unnamed: D11.2, SW11.2
unnamed: D12.2, SW12.2
unnamed: D13.2, SW13.2
unnamed: D14.2, SW14.2
unnamed: D15.2, SW15.2
unnamed: D16.2, SW16.2
unnamed: D17.2, SW17.2
unnamed: D18.2, SW18.2
unnamed: D19.2, SW19.2
unnamed: D20.2, SW20.2
unnamed: D21.2, SW21.2
unnamed: P1.1, TRRS.A
unnamed: P2.1, TRRS.B, data.2
unnamed: JP5.2, JP9.2, OLED.1
unnamed: JP4.2, JP8.2, OLED.2
unnamed: JP3.2, JP7.2, OLED.3
unnamed: JP2.2, JP6.2, OLED.4
unnamed: L1.1, L7.3
unnamed: L1.3, L2.1
unnamed: L2.3, L8.1
unnamed: L3.1, L9.3
unnamed: L3.3, L4.1
unnamed: L5.3, L6.1
unnamed: L4.3, L10.1
unnamed: L10.3, L16.1
unnamed: L11.1, L17.3
unnamed: L5.1, L11.3
unnamed: L6.3, L12.1
unnamed: L12.3, L18.1
unnamed: L7.1, L13.3
unnamed: L8.3, L14.1
unnamed: L14.3, L15.1
unnamed: L9.1, L15.3
unnamed: L16.3, L19.1
unnamed: L17.1, L20.3
unnamed: L18.3, L21.1
unnamed: L19.3, L20.1
unnamed: L21.3, L27.1
unnamed: L22.1, L25.3
unnamed: L22.3, L23.1
unnamed: L23.3, L24.1
unnamed: L25.1, L26.3
unnamed: L26.1, L27.3
SCL: JP4.1, JP7.1, R2.2, U1.6
SDA: JP5.1, JP6.1, R1.2, U1.5
VCC: J3.3, JP3.1, JP8.1, L1.4, L2.4, L3.4, L4.4, L5.4, L6.4, L7.4, L8.4, L9.4, L10.4, L11.4, L12.4, L13.4, L14.4, L15.4, L16.4, L17.4, L18.4, L19.4, L20.4, L21.4, L22.4, L23.4, L24.4, L25.4, L26.4, L27.4, R1.1, R2.1, TRRS.D, U1.21
col0: SW1.1, SW7.1, SW13.1, U1.20
col1: SW2.1, SW8.1, SW14.1, U1.19
col2: SW3.1, SW9.1, SW15.1, U1.18
col3: SW4.1, SW10.1, SW16.1, SW19.1, U1.17
col4: SW5.1, SW11.1, SW17.1, SW20.1, U1.16
col5: SW6.1, SW12.1, SW18.1, SW21.1, U1.15
data: U1.2, data.1
reset: RSW1.1, U1.22
row0: D1.1, D2.1, D3.1, D4.1, D5.1, D6.1, U1.7
row1: D7.1, D8.1, D9.1, D10.1, D11.1, D12.1, U1.8
row2: D13.1, D14.1, D15.1, D16.1, D17.1, D18.1, U1.9
row3: D19.1, D20.1, D21.1, U1.10

## Commit log

2022-03-18 seems functional but I haven't done a thorough test
2022-03-18 corrected silk text
2022-03-18 added an expertly-drawn unicorn logo
2022-03-18 added the first pcb 3d snapshot from kicad. Also, DRC'd the edge cuts so that all polygons join up nicely
2022-03-18 trying to sort out git asking for credentials: modified the .git/config file so that it uses SSH, not sure if this will work
2022-03-18 I messed up the previous config edit. Second try
